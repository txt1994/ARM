# Keil uVision project led.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407_427
  c include: ..\Cmsis;..\Interrupt;..\Library;..\User;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Boot
    ../Boot/: startup_gd32f407_427.s
  group Cmsis
    ../Cmsis/: system_gd32f4xx.c
  group Interrupt
    ../Interrupt/: gd32f4xx_it.c
  group Library
    ../Library/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group User
    ../User/: main.c gd32f4xx_libopt.h
