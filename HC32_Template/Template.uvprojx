# Keil uVision project Template.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,
  c include: .\Boot;.\Library;.\User;.\User\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  group Doc
    ./Doc/: Readme.txt
  group Library
    ./Library/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_dmc.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_eth.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mau.c hc32_ll_mpu.c hc32_ll_nfc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_smc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c hc32_ll_wdt.c hc32f4a0_ll_interrupts_share.c
  group Boot
    ./Boot/: system_hc32f4a0sitb.c startup_hc32f4a0sitb.s
  group User
    ./User/: main.c hc32f4xx_conf.h hc32f4a0sitb.h
target release (6190000::V6.19::ARMCLANG)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: as above
  output: Template
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HC32F4A0,USE_DDL_DRIVER,
  c include: .\Boot;.\Library;.\User;.\User\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
